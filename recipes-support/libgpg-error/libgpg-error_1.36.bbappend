FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://libgpg-error-1.36-gawk5-support.patch "
